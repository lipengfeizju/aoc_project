Commit message: fix small bugs

File: src/scarab_sim/racecar/simulation/racecar_description/urdf/racecar.xacro (robot description, xacro)
@@ -7,5 +7,5 @@
     <visual>
       <xacro:chassis_geometry/>
-      <material name="red" />
+      <material name="blue" />
     </visual>
   </link>
